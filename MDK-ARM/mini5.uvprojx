# Keil uVision project mini5.uvprojx, settings and files
target mini5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: mini5 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;                ../Drivers/STM32G0xx_HAL_Driver/Inc;                ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;                ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;                ../Drivers/CMSIS/Include;                ..\decadriver;                ..\mydriver;                ..\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../mydriver/: deca_instance.c deca_table.c atcmd.c
    ../STMFLASH/: flash_info.c stmflash.c
    ../Core/Src/: main.c gpio.c dma.c iwdg.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_iwdg.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group decawave
    ../decadriver/: deca_device.c deca_mutex.c deca_params_init.c deca_range_tables.c deca_spi.c port.c
software components: CMSIS:CORE 4.3.0
